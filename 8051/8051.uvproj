# Keil uVision project 8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ../Lib/: timer.c Delay.c transport.c realtime.c display.c ADC0804.c sensor.c
    ./: main.c cript.c
